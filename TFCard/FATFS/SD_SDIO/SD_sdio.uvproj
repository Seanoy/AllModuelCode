# Keil uVision project SD_sdio.uvproj, settings and files
target SD_sdio (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SD_sdio +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\FATFS_V0.09\src;.\HARDWARE\sdio_sd;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;..\SD_SDIO;.\USER;.\FATFS_V0.09\exfuns;.\MALLOC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group CODE
    ./CORE/: startup_stm32f10x_hd.s core_cm3.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group STM32F10x_FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_usart.c
  group HARDWEAR
    ./HARDWARE/sdio_sd/: sdio_sd.c
  group FATFS_09
    ./FATFS_V0.09/src/: diskio.c ff.c
    ./FATFS_V0.09/exfuns/: exfuns.c
    ./FATFS_V0.09/src/option/: cc936.c
  group MALLOC
    ./MALLOC/: malloc.c
