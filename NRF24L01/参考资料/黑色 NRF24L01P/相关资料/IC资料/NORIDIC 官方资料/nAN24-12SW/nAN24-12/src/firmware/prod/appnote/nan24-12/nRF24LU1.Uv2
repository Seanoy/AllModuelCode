### uVision2 Project, (C) Keil Software
### Do not modify !

Target (nRF24LU1), 0x0000 // Tools: 'MCS-51'

Group (App)
Group (HAL)
Group (ShockBurst)
Group (Enhanced ShockBurst)
Group (Enhanced ShockBurst w/Bidirectional data)

File 1,1,<.\main.c><main.c>
File 1,1,<.\radio.c><radio.c>
File 1,1,<.\system.c><system.c>
File 1,1,<.\lu1_bfb\mcu.c><mcu.c>
File 2,1,<..\..\..\arch\hal\nrf24l01\hal_nrf_l01.c><hal_nrf_l01.c>
File 2,1,<..\..\..\arch\hal\nrf24lu1\hal_nrf_hw.c><hal_nrf_hw.c>
File 3,1,<.\sb\radio_sb.c><radio_sb.c>
File 3,1,<.\sb\application_sb.c><application_sb.c>
File 4,1,<.\esb\radio_esb.c><radio_esb.c>
File 4,1,<.\esb\application_esb.c><application_esb.c>
File 5,1,<.\pl\radio_pl.c><radio_pl.c>
File 5,1,<.\pl\application_pl.c><application_pl.c>


Options 1,0,0  // Target 'nRF24LU1'
 Device (R80515 Core)
 Vendor (Cast, Inc.)
 Cpu (IRAM(0-0xFF) CLOCK(24000000) MODC2 MDU_R515)
 FlashUt ()
 StupF ("LIB\STARTUP.A51" ("Standard 8051 Startup Code"))
 FlashDR ()
 DevID (3622)
 Rgf (REG515.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin (C:\Keil\C51\BIN\)
 EnvInc ()
 EnvLib ()
 EnvReg ()
 OrgReg (ÿCast\)
 TgStat=16
 OutDir (.\obj\)
 OutName (nRF24LU1)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\lst\)
 HexSel=0
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 MODEL5=0
 RTOS5=0
 ROMSZ5=2
 DHOLD5=0
 XHOLD5=0
 T51FL=671088656
 XT51FL=0
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,128,0,0,0,8,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 1,0,0,0,0,0,0,0,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,0,0,0,0,0,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 IROM512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=21646608
 C51VA=0
 C51MSC ()
 C51DEF (nRF24LU1__)
 C51UDF ()
 INCC5 (.\lu1_bfb;..\..\..\arch\hal\include;..\..\..\arch\nrf24lu1;..\..\..\arch\hal\nrf24lu1)
 AX51FL=4
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=292
 LX51OVL ()
 LX51MSC ()
 LX51DWN (15,16)
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS ()
 LX51COB ()
 LX51XDB (0X8000-0X87FF)
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)()(DCore51.DLL)(-pR80515)(S8051.DLL)()(T500.DLL)(-p515)
  OPTDBG 49150,-1,()()()()()()()()()() (C:\PROGRA~1\Fs2\Cast51\Bin\fs2keil515.dll)()()()
 FLASH1 { 1,0,0,0,1,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (BIN\SiC8051F.dll)
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

