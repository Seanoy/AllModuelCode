### uVision2 Project, (C) Keil Software
### Do not modify !

Target (nRF24L01), 0x0000 // Tools: 'MCS-51'

Group (App)
Group (HAL)
Group (ShockBurst)
Group (Enhanced ShockBurst)
Group (Enhanced ShockBurst w/Bidirectional data)

File 1,1,<.\main.c><main.c> 0x0 
File 1,1,<.\radio.c><radio.c> 0x0 
File 1,1,<.\system.c><system.c> 0x0 
File 1,1,<.\l01_bfb\mcu.c><mcu.c> 0x0 
File 2,1,<..\..\..\arch\hal\nrf24l01\hal_nrf_l01.c><hal_nrf_l01.c> 0x0 
File 2,1,<.\l01_bfb\hal_nrf_f32x_hw.c><hal_nrf_f32x_hw.c> 0x0 
File 3,1,<.\sb\radio_sb.c><radio_sb.c> 0x0 
File 3,1,<.\sb\application_sb.c><application_sb.c> 0x0 
File 4,1,<.\esb\radio_esb.c><radio_esb.c> 0x0 
File 4,1,<.\esb\application_esb.c><application_esb.c> 0x0 
File 5,1,<.\pl\radio_pl.c><radio_pl.c> 0x0 
File 5,1,<.\pl\application_pl.c><application_pl.c> 0x0 


Options 1,0,0  // Target 'nRF24L01'
 Device (C8051F320)
 Vendor (Silicon Laboratories, Inc.)
 Cpu (IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(25000000))
 FlashUt ()
 StupF ("LIB\STARTUP.A51" ("Standard 8051 Startup Code"))
 FlashDR ()
 Rgf (C8051F320.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg ()
 OrgReg (ÿCygnal\)
 TgStat=25
 OutDir (.\obj\)
 OutName (nRF24L01)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\lst\)
 HexSel=0
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 SVCSID <>
 MODEL5=2
 RTOS5=0
 ROMSZ5=2
 DHOLD5=0
 XHOLD5=0
 T51FL=98416
 XT51FL=0
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 1,0,0,0,0,0,64,0,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,0,0,0,0,8,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 IROM512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=21646608
 C51VA=0
 C51MSC ()
 C51DEF (nRF24L01__)
 C51UDF ()
 INCC5 (l01_bfb;..\..\..\arch\hal\include)
 AX51FL=4
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=292
 LX51OVL (?PR?_HAL_NRF_WRITE_REG?HAL_NRF_L01 !*,\~?PR?_HAL_NRF_READ_MULTIBYTE_REG?HAL_NRF_L01 !*)
 LX51MSC (REMOVEUNUSED)
 LX51DWN (15)
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS ()
 LX51COB ()
 LX51XDB ()
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)()(DCYG.DLL)(-pCYGF320)(S8051.DLL)()(TCYG.DLL)(-pCYGF320)
  OPTDBG 49150,8,()()()()()()()()()() (BIN\SiC8051F.dll)()()()
 FLASH1 { 1,0,0,0,1,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (BIN\SiC8051F.dll)
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

